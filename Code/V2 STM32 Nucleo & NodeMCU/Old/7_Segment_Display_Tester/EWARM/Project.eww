<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\7_Segment_Display_Tester.ewp</path>
  </project>
  <batchBuild />
</workspace>
